# IAR project GRBL1.1f.20170801-STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: GRBL; HARDWARE; STM32F10x; USB
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GRBL1.1f.20170801-STM32.hex
  ILINK.IlinkOutputFile: GRBL1.1f.20170801-STM32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCOptStrategy: 0
  group grbl
    GRBL/: config.h coolant_control.c coolant_control.h cpu_map.h defaults.h eeprom.c eeprom.h gcode.c gcode.h grbl.h jog.c jog.h limits.c limits.h main.c motion_control.c motion_control.h nuts_bolts.c nuts_bolts.h planner.c planner.h print.c print.h probe.c probe.h protocol.c protocol.h report.c report.h serial.c serial.h settings.c settings.h spindle_control.c spindle_control.h stepper.c stepper.h system.c system.h
  group hardware
    HARDWARE/: Hardware.c Hardware.h HW_Delay.c HW_Delay.h HW_EEPROM.c HW_EEPROM.h HW_EXTI.c HW_EXTI.h HW_GPIO.c HW_GPIO.h HW_INT.h HW_PWM.c HW_PWM.h HW_TIM.c HW_TIM.h HW_USBUART.c HW_USBUART.h stepper_four-phase.c stepper_four-phase.h
  group stm32f10x
    STM32F10x/: core_cm3.c core_cm3.h misc.c misc.h startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h system_stm32f10x.h
  group usb
    USB/: hw_config.c hw_config.h platform_config.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c usb_conf.h usb_core.c usb_core.h usb_def.h usb_desc.c usb_desc.h usb_endp.c usb_init.c usb_init.h usb_int.c usb_int.h usb_istr.c usb_istr.h usb_lib.h usb_mem.c usb_mem.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
